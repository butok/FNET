<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>intflash-debug</name><member><project>azure-lpcxpresso54628</project><configuration>int flash debug</configuration></member></batchDefinition><batchDefinition><name>intflash-release</name><member><project>azure-lpcxpresso54628</project><configuration>int flash release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\azure-lpcxpresso54628.ewp</path></project></workspace>
