# IAR project shell_azure-evkbimxrt1050.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: FNET_CFG_CPU_MIMXRT1052=1; FNET_CFG_CPU_SERIAL_PORT_DEFAULT=1; FNET_CFG_COMP_IAR=1; CPU_MIMXRT1052DVL6B=1; MBEDTLS_CONFIG_FILE=<fnet_mbedtls_user_config.h>; _DEBUG=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1
  ICCARM.CCDiagSuppress: Pa084,Pe549,Pa082,Pe186,Pa182,Pe1215,Pe191,Pe188
  ICCARM.CCIncludePath2: ../../../../../src/shell_azure/freertos; ../../../../../../third_party/azure_iot-1.2.8/c-utility/inc; ../../../../../../third_party/azure_iot-1.2.8/c-utility/adapters; ../../../../../../third_party/azure_iot-1.2.8/c-utility/pal; ../../../../../../third_party/azure_iot-1.2.8/c-utility/pal/generic; ../../../../../../third_party/azure_iot-1.2.8/c-utility/pal/inc; ../../../../../../third_party/azure_iot-1.2.8/iothub_client/inc; ../../../../../../third_party/azure_iot-1.2.8/certs; ../../../../../../third_party/azure_iot-1.2.8/deps/parson; ../../../../../../third_party/azure_iot-1.2.8/umqtt/inc; ../../../../../../third_party/mbedtls-2.12.0/include; ../../../../../common/startup/MIMXRT1052/drivers; ../../../../../common/startup/MIMXRT1052/xip; ../../../../../common/startup/MIMXRT1052; ../../../../../../third_party/cmsis-5.1/include; ../../../../../../fnet_stack; ../../../../../common/fnet_application; ../../../../../../third_party/freertos-9.0.0/Source/portable/iar/ARM_CM4F; ../../../../../../third_party/freertos-9.0.0/Source/include; ../../../../../../third_party/freertos-9.0.0/Source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: ../../../../../src/shell_azure/freertos; ../../../../../common/startup/MIMXRT1052/drivers; ../../../../../common/startup/MIMXRT1052/xip; ../../../../../common/startup/MIMXRT1052; ../../../../../../third_party/cmsis-5.1/include; ../../../../../../fnet_stack; ../../../../../common/fnet_application
  OBJCOPY.OOCOutputFile: app.srec
  ILINK.IlinkOutputFile: shell_azure-evkbimxrt1050.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __heap_size__=0x20000; __stack_size__=0x4000
  ILINK.IlinkIcfFile: ../../../../../common/startup/MIMXRT1052/iar/MIMXRT1052xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FNET_CFG_CPU_MIMXRT1052=1; FNET_CFG_CPU_SERIAL_PORT_DEFAULT=1; FNET_CFG_COMP_IAR=1; CPU_MIMXRT1052DVL6B=1; MBEDTLS_CONFIG_FILE=<fnet_mbedtls_user_config.h>; NDEBUG=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: evkmimxrt1050.srec
  group source
    ../../../../../src/shell_azure/freertos/: fapp_user_config.h fnet_mbedtls_user_config.h fnet_user_config.h FreeRTOSConfig.h main.c
  group freertos
    ../../../../../../third_party/freertos-9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../third_party/freertos-9.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../third_party/freertos-9.0.0/Source/portable/MemMang/: heap_3.c
  group freertos/portable
    ../../../../../../third_party/freertos-9.0.0/Source/portable/iar/ARM_CM4F/: port.c portmacro.h fsl_tickless_systick.c fsl_tickless_generic.h portasm.s
  group azure/certs
    ../../../../../../third_party/azure_iot-1.2.8/certs/: certs_azure.c certs_azure.h
  group azure/c-utility/inc/azure_c_shared_utility
    ../../../../../../third_party/azure_iot-1.2.8/c-utility/inc/azure_c_shared_utility/: agenttime.h base32.h base64.h buffer_.h condition.h connection_string_parser.h consolelogger.h const_defines.h constbuffer.h constmap.h crt_abstractions.h doublylinkedlist.h etwlogger.h etwlogger_driver.h gballoc.h hmac.h hmacsha256.h http_proxy_io.h httpapi.h httpapiex.h httpapiexsas.h httpheaders.h lock.h macro_utils.h map.h optimize_size.h optionhandler.h platform.h refcount.h sastoken.h sha.h sha-private.h shared_util_options.h singlylinkedlist.h socketio.h stdint_ce6.h string_tokenizer.h string_tokenizer_types.h strings.h strings_types.h threadapi.h tickcounter.h tls_config.h tlsio.h tlsio_mbedtls.h tlsio_options.h umock_c_prod.h uniqueid.h urlencode.h uuid.h uws_client.h uws_frame_encoder.h vector.h vector_types.h vector_types_internal.h wsio.h xio.h xlogging.h
  group azure/c-utility/adapters
    ../../../../../../third_party/azure_iot-1.2.8/c-utility/adapters/: agenttime.c httpapi_compact.c uniqueid_stub.c
  group azure/c-utility/pal/generic
    ../../../../../../third_party/azure_iot-1.2.8/c-utility/pal/generic/: refcount_os.h
  group azure/c-utility/src
    ../../../../../../third_party/azure_iot-1.2.8/c-utility/src/: base32.c base64_azure.c buffer.c connection_string_parser.c consolelogger.c constbuffer.c constmap.c crt_abstractions.c doublylinkedlist.c gballoc.c hmac_azure.c hmacsha256.c http_proxy_io.c httpapiex.c httpapiexsas.c httpheaders.c map.c optionhandler.c sastoken.c sha1_azure.c sha224.c sha384-512.c singlylinkedlist.c string_tokenizer.c strings.c urlencode.c usha.c uuid.c vector.c xio.c xlogging.c
  group azure/deps/parson
    ../../../../../../third_party/azure_iot-1.2.8/deps/parson/: parson.c parson.h
  group azure/iothub_client/inc
    ../../../../../../third_party/azure_iot-1.2.8/iothub_client/inc/: iothub.h iothub_client.h iothub_client_core.h iothub_client_core_common.h iothub_client_core_ll.h iothub_client_ll.h iothub_client_hsm.h iothub_client_options.h iothub_client_version.h iothub_device_client.h iothub_device_client_ll.h iothub_message.h iothub_transport_ll.h iothubtransporthttp.h iothubtransportmqtt.h iothubtransportmqtt_websockets.h
  group azure/iothub_client/inc/internal
    ../../../../../../third_party/azure_iot-1.2.8/iothub_client/inc/internal/: blob.h iothub_client_authorization.h iothub_client_diagnostic.h iothub_client_ll_uploadtoblob.h iothub_client_private.h iothub_client_retry_control.h iothubtransport_amqp_cbs_auth.h iothubtransport_amqp_common.h iothubtransport_amqp_connection.h iothubtransport_amqp_device.h iothubtransport_amqp_messenger.h iothubtransport_amqp_telemetry_messenger.h iothubtransport_amqp_twin_messenger.h iothubtransport_mqtt_common.h iothubtransportamqp_methods.h message_queue.h uamqp_messaging.h iothubtransport.h iothub_transport_ll_private.h
  group azure/iothub_client/src
    ../../../../../../third_party/azure_iot-1.2.8/iothub_client/src/: blob.c iothub.c iothub_client.c iothub_client_authorization.c iothub_client_core.c iothub_client_core_ll.c iothub_client_diagnostic.c iothub_client_ll.c iothub_client_ll_uploadtoblob.c iothub_client_retry_control.c iothub_message.c iothubtransport.c iothubtransport_mqtt_common.c iothubtransporthttp.c iothubtransportmqtt.c message_queue.c version_azure.c
  group azure/umqtt/inc/azure_umqtt_c
    ../../../../../../third_party/azure_iot-1.2.8/umqtt/inc/azure_umqtt_c/: mqtt_client.h mqtt_codec.h mqtt_message.h mqttconst.h
  group azure/umqtt/src
    ../../../../../../third_party/azure_iot-1.2.8/umqtt/src/: mqtt_client.c mqtt_codec.c mqtt_message.c
  group mbedTLS/include
    ../../../../../../third_party/mbedtls-2.12.0/include/mbedtls/: aes.h aesni.h arc4.h asn1.h aria.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedTLS/library
    ../../../../../../third_party/mbedtls-2.12.0/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group startup
    ../../../../../common/startup/MIMXRT1052/: board.c board.h clock_config.c clock_config.h fsl_device_registers.h system_MIMXRT1052.c system_MIMXRT1052.h MIMXRT1052.h MIMXRT1052_features.h pin_mux.h
    ../../../../../common/startup/MIMXRT1052/iar/: startup_MIMXRT1052.S
  group startup/drivers
    ../../../../../common/startup/MIMXRT1052/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_qtmr.c fsl_qtmr.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h
  group startup/xip
    ../../../../../common/startup/MIMXRT1052/xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group cmsis
    ../../../../../../third_party/cmsis-5.1/include/: core_cm7.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h cmsis_gcc.h cmsis_armcc.h
  group fnet_stack
    ../../../../../../fnet_stack/: fnet.h fnet_config.h
  group fnet_stack/port/compiler
    ../../../../../../fnet_stack/port/compiler/: fnet_comp.h fnet_comp_asm.h fnet_comp_config.h
  group fnet_stack/port/cpu
    ../../../../../../fnet_stack/port/cpu/: fnet_cpu.c fnet_cpu.h fnet_cpu_config.h
  group fnet_stack/port/cpu/lpc
    ../../../../../../fnet_stack/port/cpu/lpc/: fnet_lpc.c fnet_lpc.h fnet_lpc_config.h fnet_lpc_eth.c fnet_lpc_flash.c fnet_lpc_isr.c fnet_lpc_isr_inst.c fnet_lpc_low.S fnet_lpc_serial.c fnet_lpc_timer.c fnet_lpc_wifi.c fnet_lpc54628_config.h
  group fnet_stack/port/cpu/mcf
    ../../../../../../fnet_stack/port/cpu/mcf/: fnet_mcf.c fnet_mcf.h fnet_mcf_checksum.s fnet_mcf_config.h fnet_mcf_eth.c fnet_mcf_flash.c fnet_mcf_isr.s fnet_mcf_isr_inst.c fnet_mcf_low.s fnet_mcf_serial.c fnet_mcf_timer.c fnet_mcf51cn128_config.h fnet_mcf52235_config.h fnet_mcf52259_config.h fnet_mcf5235_config.h fnet_mcf5282_config.h fnet_mcf54418_config.h
  group fnet_stack/port/cpu/mimxrt
    ../../../../../../fnet_stack/port/cpu/mimxrt/: fnet_mimxrt.c fnet_mimxrt.h fnet_mimxrt_config.h fnet_mimxrt_eth.c fnet_mimxrt_isr.c fnet_mimxrt_isr_inst.c fnet_mimxrt_low.S fnet_mimxrt_serial.c fnet_mimxrt_timer.c fnet_mimxrt_wifi.c fnet_mimxrt1052_config.h fnet_mimxrt1062_config.h
  group fnet_stack/port/cpu/mk
    ../../../../../../fnet_stack/port/cpu/mk/: fnet_mk.c fnet_mk.h fnet_mk_config.h fnet_mk_eth.c fnet_mk_flash.c fnet_mk_isr.c fnet_mk_isr_inst.c fnet_mk_low.S fnet_mk_serial.c fnet_mk_timer.c fnet_mk_wifi.c fnet_mk60dn512_config.h fnet_mk60fn1_config.h fnet_mk60n512_config.h fnet_mk64fn1_config.h fnet_mk66fn2_config.h fnet_mk70fn1_config.h
  group fnet_stack/port/cpu/mpc
    ../../../../../../fnet_stack/port/cpu/mpc/: fnet_mpc.c fnet_mpc.h fnet_mpc_config.h fnet_mpc_eth.c fnet_mpc_isr.c fnet_mpc_isr_inst.c fnet_mpc_serial.c fnet_mpc_timer.c fnet_mpc564xbc_config.h fnet_mpc5566_config.h fnet_mpc5668g_config.h fnet_mpc5744p_config.h fnet_mpc5744p_flash.c fnet_mpc5744p_cache.c
  group fnet_stack/port/netif/fec
    ../../../../../../fnet_stack/port/netif/fec/: fnet_fec.c fnet_fec.h
  group fnet_stack/port/netif/qca
    ../../../../../../fnet_stack/port/netif/qca/: fnet_qca.c fnet_qca.h
  group fnet_stack/port/netif/enet
    ../../../../../../fnet_stack/port/netif/enet/: fnet_enet.c fnet_enet.h
  group fnet_stack/service
    ../../../../../../fnet_stack/service/: fnet_service.c fnet_service.h fnet_service_config.h fnet_service_prv.h
  group fnet_stack/service/autoip
    ../../../../../../fnet_stack/service/autoip/: fnet_autoip.c fnet_autoip.h fnet_autoip_config.h
  group fnet_stack/service/azure
    ../../../../../../fnet_stack/service/azure/: fnet_azure_platform.c fnet_azure_socketio.c fnet_azure_tlsio.c fnet_azure.h fnet_azure_config.h fnet_azure_lock.c fnet_azure_threadapi.c fnet_azure_tickcounter.c
  group fnet_stack/service/bench
    ../../../../../../fnet_stack/service/bench/: fnet_bench_cln.c fnet_bench_cln.h fnet_bench_config.h fnet_bench_srv.c fnet_bench_srv.h
  group fnet_stack/service/dhcp
    ../../../../../../fnet_stack/service/dhcp/: fnet_dhcp.c fnet_dhcp_cln.c fnet_dhcp_cln.h fnet_dhcp_config.h fnet_dhcp_prv.h fnet_dhcp_srv.c fnet_dhcp_srv.h
  group fnet_stack/service/dns
    ../../../../../../fnet_stack/service/dns/: fnet_dns.c fnet_dns.h fnet_dns_config.h fnet_dns_prv.h
  group fnet_stack/service/flash
    ../../../../../../fnet_stack/service/flash/: fnet_flash.c fnet_flash.h fnet_flash_config.h
  group fnet_stack/service/fs
    ../../../../../../fnet_stack/service/fs/: fnet_fs.c fnet_fs.h fnet_fs_config.h fnet_fs_prv.h fnet_fs_rom.c fnet_fs_rom.h fnet_fs_root.c fnet_fs_root.h
  group fnet_stack/service/http
    ../../../../../../fnet_stack/service/http/: fnet_http_cln.c fnet_http_cln.h fnet_http_srv.c fnet_http_srv.h fnet_http_srv_auth.c fnet_http_srv_auth.h fnet_http_srv_auth_prv.h fnet_http_srv_cgi.c fnet_http_srv_cgi.h fnet_http_config.h fnet_http_srv_get.c fnet_http_srv_post.c fnet_http_srv_post.h fnet_http_srv_prv.h fnet_http_srv_ssi.c fnet_http_srv_ssi.h fnet_http_srv_ssi_prv.h
  group fnet_stack/service/link
    ../../../../../../fnet_stack/service/link/: fnet_link.c fnet_link.h fnet_link_config.h
  group fnet_stack/service/llmnr
    ../../../../../../fnet_stack/service/llmnr/: fnet_llmnr.c fnet_llmnr.h fnet_llmnr_config.h
  group fnet_stack/service/mdns
    ../../../../../../fnet_stack/service/mdns/: fnet_mdns.c fnet_mdns.h fnet_mdns_config.h
  group fnet_stack/service/ping
    ../../../../../../fnet_stack/service/ping/: fnet_ping.c fnet_ping.h fnet_ping_config.h
  group fnet_stack/service/serial
    ../../../../../../fnet_stack/service/serial/: fnet_serial.c fnet_serial.h fnet_serial_config.h
  group fnet_stack/service/shell
    ../../../../../../fnet_stack/service/shell/: fnet_shell.c fnet_shell.h fnet_shell_config.h
  group fnet_stack/service/sntp
    ../../../../../../fnet_stack/service/sntp/: fnet_sntp.c fnet_sntp.h fnet_sntp_config.h
  group fnet_stack/service/telnet
    ../../../../../../fnet_stack/service/telnet/: fnet_telnet.c fnet_telnet.h fnet_telnet_config.h
  group fnet_stack/service/tftp
    ../../../../../../fnet_stack/service/tftp/: fnet_tftp.h fnet_tftp_cln.c fnet_tftp_cln.h fnet_tftp_config.h fnet_tftp_srv.c fnet_tftp_srv.h
  group fnet_stack/service/tls
    ../../../../../../fnet_stack/service/tls/: fnet_tls.c fnet_tls.h fnet_tls_config.h
  group fnet_stack/stack
    ../../../../../../fnet_stack/stack/: fnet_arp.c fnet_arp.h fnet_arp_prv.h fnet_assert.h fnet_checksum.c fnet_checksum.h fnet_checksum_prv.h fnet_debug.h fnet_error.c fnet_error.h fnet_eth.c fnet_eth.h fnet_eth_prv.h fnet_icmp4.c fnet_icmp4.h fnet_icmp6.c fnet_icmp6.h fnet_igmp.c fnet_igmp.h fnet_inet.c fnet_inet.h fnet_ip.c fnet_ip_prv.h fnet_ip4.h fnet_ip4_prv.h fnet_ip4.c fnet_ip6.c fnet_ip6.h fnet_ip6_prv.h fnet_isr.c fnet_isr.h fnet_loop.c fnet_loop.h fnet_mempool.c fnet_mempool.h fnet_mld.c fnet_mld.h fnet_nd6.c fnet_nd6.h fnet_netbuf.c fnet_netbuf.h fnet_netbuf_prv.h fnet_netif.c fnet_netif.h fnet_netif_prv.h fnet_prot.c fnet_prot.h fnet_raw.c fnet_raw.h fnet_socket.c fnet_socket.h fnet_socket_prv.h fnet_stack.c fnet_stack.h fnet_stack_config.h fnet_stack_prv.h fnet_stdlib.c fnet_stdlib.h fnet_tcp.c fnet_tcp.h fnet_timer.c fnet_timer.h fnet_timer_prv.h fnet_udp.c fnet_udp.h fnet_wifi.c fnet_wifi.h fnet_wifi_prv.h
  group fnet_application
    ../../../../../common/fnet_application/: fapp.c fapp.h fapp_azure.c fapp_azure.h fapp_autoip.c fapp_autoip.h fapp_bench.c fapp_bench.h fapp_config.h fapp_dhcp.c fapp_dhcp.h fapp_dns.c fapp_dns.h fapp_fs.c fapp_fs.h fapp_fs_image.c fapp_freertos.c fapp_freertos.h fapp_http.c fapp_http.h fapp_link.c fapp_link.h fapp_llmnr.c fapp_llmnr.h fapp_mdns.c fapp_mdns.h fapp_mem.c fapp_mem.h fapp_netif.c fapp_netif.h fapp_params.c fapp_params.h fapp_params_prv.h fapp_ping.c fapp_ping.h fapp_prv.h fapp_setget.c fapp_setget.h fapp_shell.c fapp_shell.h fapp_sntp.c fapp_sntp.h fapp_telnet.c fapp_telnet.h fapp_tftp.c fapp_tftp.h fapp_wifi.c fapp_wifi.h
