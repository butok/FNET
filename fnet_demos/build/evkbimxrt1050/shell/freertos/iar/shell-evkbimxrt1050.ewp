# IAR project shell-evkbimxrt1050.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: FNET_CFG_CPU_MIMXRT1052=1; FNET_CFG_CPU_SERIAL_PORT_DEFAULT=1; FNET_CFG_COMP_IAR=1; CPU_MIMXRT1052DVL6B=1; NDEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pa182
  ICCARM.CCIncludePath2: ../../../../../src/shell/freertos; ../../../../../common/startup/MIMXRT1052/drivers; ../../../../../common/startup/MIMXRT1052/xip; ../../../../../common/startup/MIMXRT1052; ../../../../../../third_party/cmsis-5.1/include; ../../../../../../fnet_stack; ../../../../../common/fnet_application; ../../../../../../third_party/freertos-9.0.0/Source/portable/iar/ARM_CM4F; ../../../../../../third_party/freertos-9.0.0/Source/include; ../../../../../../third_party/freertos-9.0.0/Source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: ../../../../../src/shell/freertos; ../../../../../common/startup/MIMXRT1052/drivers; ../../../../../common/startup/MIMXRT1052/xip; ../../../../../common/startup/MIMXRT1052; ../../../../../../third_party/cmsis-5.1/include; ../../../../../../fnet_stack; ../../../../../common/fnet_application
  OBJCOPY.OOCOutputFile: app.srec
  ILINK.IlinkOutputFile: shell-evkbimxrt1050.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __heap_size__=0x20000; __stack_size__=0x4000
  ILINK.IlinkIcfFile: ../../../../../common/startup/MIMXRT1052/iar/MIMXRT1052xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FNET_CFG_CPU_MIMXRT1052=1; FNET_CFG_CPU_SERIAL_PORT_DEFAULT=1; FNET_CFG_COMP_IAR=1; CPU_MIMXRT1052DVL6B=1; _DEBUG=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1
  ICCARM.CCOptLevel: 1
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: ../../../../../common/startup/MIMXRT1052/iar/MIMXRT1052xxxxx_flexspi_nor.icf
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FNET_CFG_CPU_MIMXRT1052=1; FNET_CFG_CPU_SERIAL_PORT_DEFAULT=1; FNET_CFG_COMP_IAR=1; CPU_MIMXRT1052DVL6B=1; NDEBUG=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: evkmimxrt1050.srec
  ILINK.IlinkIcfFile: as above
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FNET_CFG_CPU_MIMXRT1052=1; FNET_CFG_CPU_SERIAL_PORT_DEFAULT=1; FNET_CFG_COMP_IAR=1; CPU_MIMXRT1052DVL6B=1; _DEBUG=1; SKIP_SYSCLK_INIT=1
  ICCARM.CCOptLevel: 1
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: ../../../../../common/startup/MIMXRT1052/iar/MIMXRT1052xxxxx_sdram.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FNET_CFG_CPU_MIMXRT1052=1; FNET_CFG_CPU_SERIAL_PORT_DEFAULT=1; FNET_CFG_COMP_IAR=1; CPU_MIMXRT1052DVL6B=1; NDEBUG=1; SKIP_SYSCLK_INIT=1
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: as above
configuration sdram_txt_debug (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 1
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: ../../../../../common/startup/MIMXRT1052/iar/MIMXRT1052xxxxx_sdram_txt.icf
configuration sdram_txt_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: as above
  group source
    ../../../../../src/shell/freertos/: fapp_user_config.h fnet_user_config.h FreeRTOSConfig.h main.c
  group freertos
    ../../../../../../third_party/freertos-9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../third_party/freertos-9.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../third_party/freertos-9.0.0/Source/portable/MemMang/: heap_3.c
  group freertos/portable
    ../../../../../../third_party/freertos-9.0.0/Source/portable/iar/ARM_CM4F/: port.c portmacro.h fsl_tickless_systick.c fsl_tickless_generic.h portasm.s
  group startup
    ../../../../../common/startup/MIMXRT1052/: board.c board.h clock_config.c clock_config.h fsl_device_registers.h system_MIMXRT1052.c system_MIMXRT1052.h MIMXRT1052.h MIMXRT1052_features.h pin_mux.h
    ../../../../../common/startup/MIMXRT1052/iar/: startup_MIMXRT1052.S
  group startup/drivers
    ../../../../../common/startup/MIMXRT1052/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_qtmr.c fsl_qtmr.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h
  group startup/xip
    ../../../../../common/startup/MIMXRT1052/xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group cmsis
    ../../../../../../third_party/cmsis-5.1/include/: core_cm7.h cmsis_compiler.h cmsis_version.h cmsis_iccarm.h cmsis_gcc.h cmsis_armcc.h
  group fnet_stack
    ../../../../../../fnet_stack/: fnet.h fnet_config.h
  group fnet_stack/port/compiler
    ../../../../../../fnet_stack/port/compiler/: fnet_comp.h fnet_comp_asm.h fnet_comp_config.h
  group fnet_stack/port/cpu
    ../../../../../../fnet_stack/port/cpu/: fnet_cpu.c fnet_cpu.h fnet_cpu_config.h
  group fnet_stack/port/cpu/lpc
    ../../../../../../fnet_stack/port/cpu/lpc/: fnet_lpc.c fnet_lpc.h fnet_lpc_config.h fnet_lpc_eth.c fnet_lpc_flash.c fnet_lpc_isr.c fnet_lpc_isr_inst.c fnet_lpc_low.S fnet_lpc_serial.c fnet_lpc_timer.c fnet_lpc_wifi.c fnet_lpc54628_config.h
  group fnet_stack/port/cpu/mcf
    ../../../../../../fnet_stack/port/cpu/mcf/: fnet_mcf.c fnet_mcf.h fnet_mcf_checksum.s fnet_mcf_config.h fnet_mcf_eth.c fnet_mcf_flash.c fnet_mcf_isr.s fnet_mcf_isr_inst.c fnet_mcf_low.s fnet_mcf_serial.c fnet_mcf_timer.c fnet_mcf51cn128_config.h fnet_mcf52235_config.h fnet_mcf52259_config.h fnet_mcf5235_config.h fnet_mcf5282_config.h fnet_mcf54418_config.h
  group fnet_stack/port/cpu/mimxrt
    ../../../../../../fnet_stack/port/cpu/mimxrt/: fnet_mimxrt.c fnet_mimxrt.h fnet_mimxrt_config.h fnet_mimxrt_eth.c fnet_mimxrt_isr.c fnet_mimxrt_isr_inst.c fnet_mimxrt_low.S fnet_mimxrt_serial.c fnet_mimxrt_timer.c fnet_mimxrt_wifi.c fnet_mimxrt1052_config.h
  group fnet_stack/port/cpu/mk
    ../../../../../../fnet_stack/port/cpu/mk/: fnet_mk.c fnet_mk.h fnet_mk_config.h fnet_mk_eth.c fnet_mk_flash.c fnet_mk_isr.c fnet_mk_isr_inst.c fnet_mk_low.S fnet_mk_serial.c fnet_mk_timer.c fnet_mk_wifi.c fnet_mk60dn512_config.h fnet_mk60fn1_config.h fnet_mk60n512_config.h fnet_mk64fn1_config.h fnet_mk66fn2_config.h fnet_mk70fn1_config.h
  group fnet_stack/port/cpu/mpc
    ../../../../../../fnet_stack/port/cpu/mpc/: fnet_mpc.c fnet_mpc.h fnet_mpc_config.h fnet_mpc_eth.c fnet_mpc_isr.c fnet_mpc_isr_inst.c fnet_mpc_serial.c fnet_mpc_timer.c fnet_mpc564xbc_config.h fnet_mpc5566_config.h fnet_mpc5668g_config.h fnet_mpc5744p_config.h fnet_mpc5744p_flash.c fnet_mpc5744p_cache.c
  group fnet_stack/port/netif/fec
    ../../../../../../fnet_stack/port/netif/fec/: fnet_fec.c fnet_fec.h
  group fnet_stack/port/netif/qca
    ../../../../../../fnet_stack/port/netif/qca/: fnet_qca.c fnet_qca.h
  group fnet_stack/port/netif/enet
    ../../../../../../fnet_stack/port/netif/enet/: fnet_enet.c fnet_enet.h
  group fnet_stack/service
    ../../../../../../fnet_stack/service/: fnet_service.c fnet_service.h fnet_service_config.h fnet_service_prv.h
  group fnet_stack/service/autoip
    ../../../../../../fnet_stack/service/autoip/: fnet_autoip.c fnet_autoip.h fnet_autoip_config.h
  group fnet_stack/service/azure
    ../../../../../../fnet_stack/service/azure/: fnet_azure_platform.c fnet_azure_socketio.c fnet_azure_tlsio.c fnet_azure.h fnet_azure_config.h fnet_azure_lock.c fnet_azure_threadapi.c fnet_azure_tickcounter.c
  group fnet_stack/service/bench
    ../../../../../../fnet_stack/service/bench/: fnet_bench_cln.c fnet_bench_cln.h fnet_bench_config.h fnet_bench_srv.c fnet_bench_srv.h
  group fnet_stack/service/dhcp
    ../../../../../../fnet_stack/service/dhcp/: fnet_dhcp.c fnet_dhcp_cln.c fnet_dhcp_cln.h fnet_dhcp_config.h fnet_dhcp_prv.h fnet_dhcp_srv.c fnet_dhcp_srv.h
  group fnet_stack/service/dns
    ../../../../../../fnet_stack/service/dns/: fnet_dns.c fnet_dns.h fnet_dns_config.h fnet_dns_prv.h
  group fnet_stack/service/flash
    ../../../../../../fnet_stack/service/flash/: fnet_flash.c fnet_flash.h fnet_flash_config.h
  group fnet_stack/service/fs
    ../../../../../../fnet_stack/service/fs/: fnet_fs.c fnet_fs.h fnet_fs_config.h fnet_fs_prv.h fnet_fs_rom.c fnet_fs_rom.h fnet_fs_root.c fnet_fs_root.h
  group fnet_stack/service/http
    ../../../../../../fnet_stack/service/http/: fnet_http_cln.c fnet_http_cln.h fnet_http_srv.c fnet_http_srv.h fnet_http_srv_auth.c fnet_http_srv_auth.h fnet_http_srv_auth_prv.h fnet_http_srv_cgi.c fnet_http_srv_cgi.h fnet_http_config.h fnet_http_srv_get.c fnet_http_srv_post.c fnet_http_srv_post.h fnet_http_srv_prv.h fnet_http_srv_ssi.c fnet_http_srv_ssi.h fnet_http_srv_ssi_prv.h
  group fnet_stack/service/link
    ../../../../../../fnet_stack/service/link/: fnet_link.c fnet_link.h fnet_link_config.h
  group fnet_stack/service/llmnr
    ../../../../../../fnet_stack/service/llmnr/: fnet_llmnr.c fnet_llmnr.h fnet_llmnr_config.h
  group fnet_stack/service/mdns
    ../../../../../../fnet_stack/service/mdns/: fnet_mdns.c fnet_mdns.h fnet_mdns_config.h
  group fnet_stack/service/ping
    ../../../../../../fnet_stack/service/ping/: fnet_ping.c fnet_ping.h fnet_ping_config.h
  group fnet_stack/service/serial
    ../../../../../../fnet_stack/service/serial/: fnet_serial.c fnet_serial.h fnet_serial_config.h
  group fnet_stack/service/shell
    ../../../../../../fnet_stack/service/shell/: fnet_shell.c fnet_shell.h fnet_shell_config.h
  group fnet_stack/service/sntp
    ../../../../../../fnet_stack/service/sntp/: fnet_sntp.c fnet_sntp.h fnet_sntp_config.h
  group fnet_stack/service/telnet
    ../../../../../../fnet_stack/service/telnet/: fnet_telnet.c fnet_telnet.h fnet_telnet_config.h
  group fnet_stack/service/tftp
    ../../../../../../fnet_stack/service/tftp/: fnet_tftp.h fnet_tftp_cln.c fnet_tftp_cln.h fnet_tftp_config.h fnet_tftp_srv.c fnet_tftp_srv.h
  group fnet_stack/service/tls
    ../../../../../../fnet_stack/service/tls/: fnet_tls.c fnet_tls.h fnet_tls_config.h
  group fnet_stack/stack
    ../../../../../../fnet_stack/stack/: fnet_arp.c fnet_arp.h fnet_arp_prv.h fnet_assert.h fnet_checksum.c fnet_checksum.h fnet_checksum_prv.h fnet_debug.h fnet_error.c fnet_error.h fnet_eth.c fnet_eth.h fnet_eth_prv.h fnet_icmp4.c fnet_icmp4.h fnet_icmp6.c fnet_icmp6.h fnet_igmp.c fnet_igmp.h fnet_inet.c fnet_inet.h fnet_ip.c fnet_ip_prv.h fnet_ip4.h fnet_ip4_prv.h fnet_ip4.c fnet_ip6.c fnet_ip6.h fnet_ip6_prv.h fnet_isr.c fnet_isr.h fnet_loop.c fnet_loop.h fnet_mempool.c fnet_mempool.h fnet_mld.c fnet_mld.h fnet_nd6.c fnet_nd6.h fnet_netbuf.c fnet_netbuf.h fnet_netbuf_prv.h fnet_netif.c fnet_netif.h fnet_netif_prv.h fnet_prot.c fnet_prot.h fnet_raw.c fnet_raw.h fnet_socket.c fnet_socket.h fnet_socket_prv.h fnet_stack.c fnet_stack.h fnet_stack_config.h fnet_stack_prv.h fnet_stdlib.c fnet_stdlib.h fnet_tcp.c fnet_tcp.h fnet_timer.c fnet_timer.h fnet_timer_prv.h fnet_udp.c fnet_udp.h fnet_wifi.c fnet_wifi.h fnet_wifi_prv.h
  group fnet_application
    ../../../../../common/fnet_application/: fapp.c fapp.h fapp_azure.c fapp_azure.h fapp_autoip.c fapp_autoip.h fapp_bench.c fapp_bench.h fapp_config.h fapp_dhcp.c fapp_dhcp.h fapp_dns.c fapp_dns.h fapp_fs.c fapp_fs.h fapp_fs_image.c fapp_freertos.c fapp_freertos.h fapp_http.c fapp_http.h fapp_link.c fapp_link.h fapp_llmnr.c fapp_llmnr.h fapp_mdns.c fapp_mdns.h fapp_mem.c fapp_mem.h fapp_netif.c fapp_netif.h fapp_params.c fapp_params.h fapp_params_prv.h fapp_ping.c fapp_ping.h fapp_prv.h fapp_setget.c fapp_setget.h fapp_shell.c fapp_shell.h fapp_sntp.c fapp_sntp.h fapp_telnet.c fapp_telnet.h fapp_tftp.c fapp_tftp.h fapp_wifi.c fapp_wifi.h
