<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>flexspinor-debug</name><member><project>shell-evkbimxrt1050</project><configuration>flexspi_nor_debug</configuration></member></batchDefinition><batchDefinition><name>flexspinor-release</name><member><project>shell-evkbimxrt1050</project><configuration>flexspi_nor_release</configuration></member></batchDefinition><batchDefinition><name>release</name><member><project>shell-evkbimxrt1050</project><configuration>release</configuration></member></batchDefinition><batchDefinition><name>sdram-debug</name><member><project>shell-evkbimxrt1050</project><configuration>sdram_debug</configuration></member></batchDefinition><batchDefinition><name>sdram-release</name><member><project>shell-evkbimxrt1050</project><configuration>sdram_release</configuration></member></batchDefinition><batchDefinition><name>sdram_txt-debug</name><member><project>shell-evkbimxrt1050</project><configuration>sdram_txt_debug</configuration></member></batchDefinition><batchDefinition><name>sdram_txt-release</name><member><project>shell-evkbimxrt1050</project><configuration>sdram_txt_release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\shell-evkbimxrt1050.ewp</path></project></workspace>
