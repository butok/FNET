<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>flexspinor-debug</name><member><project>shell_tls-evkbimxrt1050</project><configuration>flexspi_nor_debug</configuration></member></batchDefinition><batchDefinition><name>flexspinor-release</name><member><project>shell_tls-evkbimxrt1050</project><configuration>flexspi_nor_release</configuration></member></batchDefinition></batchBuild><project><path>$WS_DIR$\shell_tls-evkbimxrt1050.ewp</path></project></workspace>
