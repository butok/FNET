# IAR project shell_mbedtls.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; FNET_CFG_COMP_IAR=1; CPU_MK64FN1M0VMD12; MBEDTLS_CONFIG_FILE="fnet_mbedtls_user_config.h"; FRDM_K64F; FREEDOM; FNET_CFG_CPU_MK64FN1=1; FNET_CFG_CPU_SERIAL_PORT_DEFAULT=0u
  ICCARM.CCDiagSuppress: Pe177,Pa082,Pa084,Pe549,Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../common/startup/CMSIS; ../../../../common/startup; ..; ../../../../src/shell_mbedtls; ../../../../../fnet_stack; ../../../../common/fnet_application; ../../../../../third_party/mbedtls-2.4.2/include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; FNET_CFG_COMP_IAR=1; FNET_CFG_CPU_MK64FN1=1
  AARM.AUserIncludes: ../../../../src/shell_mbedtls; ../../../../../fnet_stack
  OBJCOPY.OOCOutputFile: fnet_firmware.srec
  ILINK.IlinkOutputFile: shell_mbedtls.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __ram_vector_table__=1; __heap_size__=0x15000
  ILINK.IlinkIcfFile: ../../../../common/startup/MK64F12/iar/MK64FN1M0xxx12_flash_fnet.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; FNET_CFG_COMP_IAR=1; CPU_MK64FN1M0VMD12; MBEDTLS_CONFIG_FILE="fnet_mbedtls_user_config.h"; FRDM_K64F; FREEDOM; FNET_CFG_CPU_MK64FN1=1; FNET_CFG_CPU_SERIAL_PORT_DEFAULT=0u
  ICCARM.CCOptLevel: 3
  AARM.ADefines: FNET_CFG_COMP_IAR=1; FNET_CFG_CPU_MK64FN1=1
  group startup
    ../../../../common/startup/MK64F12/iar/: startup_MK64F12.s
    ../../../../common/startup/MK64F12/: clock_config.c clock_config.h fsl_clock.c fsl_clock.h fsl_common.h fsl_device_registers.h fsl_sbrk.c fsl_smc.c fsl_smc.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
  group source
    ../../../../src/shell_mbedtls/: fapp_user_config.h fnet_mbedtls_user_config.h fnet_user_config.h main.c
  group fnet_stack
    ../../../../../fnet_stack/: fnet.h fnet_config.h
  group fnet_stack/port/cpu
    ../../../../../fnet_stack/port/cpu/: fnet_cpu.c fnet_cpu.h fnet_cpu_config.h
  group fnet_stack/port/cpu/mk
    ../../../../../fnet_stack/port/cpu/mk/: fnet_mk.c fnet_mk.h fnet_mk_cache.c fnet_mk_config.h fnet_mk_eth.c fnet_mk_flash.c fnet_mk_isr.c fnet_mk_isr_inst.c fnet_mk_low.S fnet_mk_serial.c fnet_mk_timer.c fnet_mk60fn1_config.h fnet_mk60n512_config.h fnet_mk60dn512_config.h fnet_mk64fn1_config.h fnet_mk66fn2_config.h fnet_mk70fn1_config.h
  group fnet_stack/port/cpu/common
    ../../../../../fnet_stack/port/cpu/common/: fnet_fec.c fnet_fec.h
  group fnet_stack/port/compiler
    ../../../../../fnet_stack/port/compiler/: fnet_comp.h fnet_comp_asm.h fnet_comp_config.h
  group fnet_stack/services
    ../../../../../fnet_stack/services/: fnet_services.h fnet_services_config.h
  group fnet_stack/services/autoip
    ../../../../../fnet_stack/services/autoip/: fnet_autoip.c fnet_autoip.h fnet_autoip_config.h
  group fnet_stack/services/dhcp
    ../../../../../fnet_stack/services/dhcp/: fnet_dhcp.c fnet_dhcp.h fnet_dhcp_config.h
  group fnet_stack/services/dns
    ../../../../../fnet_stack/services/dns/: fnet_dns.c fnet_dns.h fnet_dns_config.h fnet_dns_prv.h
  group fnet_stack/services/mdns
    ../../../../../fnet_stack/services/mdns/: fnet_mdns.c fnet_mdns.h fnet_mdns_config.h
  group fnet_stack/services/flash
    ../../../../../fnet_stack/services/flash/: fnet_flash.c fnet_flash.h fnet_flash_config.h
  group fnet_stack/services/fs
    ../../../../../fnet_stack/services/fs/: fnet_fs.c fnet_fs.h fnet_fs_config.h fnet_fs_prv.h fnet_fs_rom.c fnet_fs_rom.h fnet_fs_root.c fnet_fs_root.h
  group fnet_stack/services/http
    ../../../../../fnet_stack/services/http/: fnet_http.c fnet_http.h fnet_http_auth.c fnet_http_auth.h fnet_http_auth_prv.h fnet_http_cgi.c fnet_http_cgi.h fnet_http_config.h fnet_http_get.c fnet_http_post.c fnet_http_post.h fnet_http_prv.h fnet_http_ssi.c fnet_http_ssi.h fnet_http_ssi_prv.h
  group fnet_stack/services/link
    ../../../../../fnet_stack/services/link/: fnet_link.c fnet_link.h fnet_link_config.h
  group fnet_stack/services/llmnr
    ../../../../../fnet_stack/services/llmnr/: fnet_llmnr.c fnet_llmnr.h fnet_llmnr_config.h
  group fnet_stack/services/ping
    ../../../../../fnet_stack/services/ping/: fnet_ping.c fnet_ping.h fnet_ping_config.h
  group fnet_stack/services/poll
    ../../../../../fnet_stack/services/poll/: fnet_poll.c fnet_poll.h
  group fnet_stack/services/serial
    ../../../../../fnet_stack/services/serial/: fnet_serial.c fnet_serial.h fnet_serial_config.h
  group fnet_stack/services/shell
    ../../../../../fnet_stack/services/shell/: fnet_shell.c fnet_shell.h fnet_shell_config.h
  group fnet_stack/services/sntp
    ../../../../../fnet_stack/services/sntp/: fnet_sntp.c fnet_sntp.h fnet_sntp_config.h
  group fnet_stack/services/telnet
    ../../../../../fnet_stack/services/telnet/: fnet_telnet.c fnet_telnet.h fnet_telnet_config.h
  group fnet_stack/services/tftp
    ../../../../../fnet_stack/services/tftp/: fnet_tftp.h fnet_tftp_cln.c fnet_tftp_cln.h fnet_tftp_config.h fnet_tftp_srv.c fnet_tftp_srv.h
  group fnet_stack/services/tls
    ../../../../../fnet_stack/services/tls/: fnet_tls.c fnet_tls.h fnet_tls_config.h
  group fnet_stack/stack
    ../../../../../fnet_stack/stack/: fnet_arp.c fnet_arp.h fnet_arp_prv.h fnet_assert.h fnet_checksum.c fnet_checksum.h fnet_debug.h fnet_error.c fnet_error.h fnet_eth.c fnet_eth.h fnet_eth_prv.h fnet_icmp4.c fnet_icmp4.h fnet_icmp6.c fnet_icmp6.h fnet_igmp.c fnet_igmp.h fnet_inet.c fnet_inet.h fnet_ip.c fnet_ip_prv.h fnet_ip4.c fnet_ip4.h fnet_ip4_prv.h fnet_ip6.c fnet_ip6.h fnet_ip6_prv.h fnet_isr.c fnet_isr.h fnet_loop.c fnet_loop.h fnet_mempool.c fnet_mempool.h fnet_mld.c fnet_mld.h fnet_nd6.c fnet_nd6.h fnet_netbuf.c fnet_netbuf.h fnet_netif.c fnet_netif.h fnet_netif_prv.h fnet_prot.c fnet_prot.h fnet_raw.c fnet_raw.h fnet_socket.c fnet_socket.h fnet_socket_prv.h fnet_stack.c fnet_stack.h fnet_stack_prv.h fnet_stack_config.h fnet_stdlib.c fnet_stdlib.h fnet_tcp.c fnet_tcp.h fnet_timer.c fnet_timer.h fnet_timer_prv.h fnet_udp.c fnet_udp.h
  group fnet_application
    ../../../../common/fnet_application/: fapp.c fapp.h fapp_autoip.c fapp_autoip.h fapp_bench.c fapp_bench.h fapp_config.h fapp_dhcp.c fapp_dhcp.h fapp_dns.c fapp_dns.h fapp_fs.c fapp_fs.h fapp_fs_image.c fapp_http.c fapp_http.h fapp_llmnr.c fapp_llmnr.h fapp_link.c fapp_link.h fapp_mem.c fapp_mem.h fapp_mdns.c fapp_mdns.h fapp_netif.c fapp_netif.h fapp_params.c fapp_params.h fapp_params_prv.h fapp_ping.c fapp_ping.h fapp_prv.h fapp_setget.c fapp_setget.h fapp_sntp.c fapp_sntp.h fapp_telnet.c fapp_telnet.h fapp_tftp.c fapp_tftp.h
  group mbedTLS/mbedTLS_include
    ../../../../../third_party/mbedtls-2.4.2/include/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbedTLS/mbedTLS_source
    ../../../../../third_party/mbedtls-2.4.2/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
