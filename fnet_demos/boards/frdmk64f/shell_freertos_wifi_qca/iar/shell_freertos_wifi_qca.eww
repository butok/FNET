<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>shell_freertos_wifi_qca</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>shell_freertos_wifi_qca</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>shell_freertos_wifi_qca</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>shell_freertos_wifi_qca</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/shell_freertos_wifi_qca.ewp</path>
  </project>
</workspace>
